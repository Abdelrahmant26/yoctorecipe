# Enable the Bonjour compatibility headers
PACKAGECONFIG:append = " libdns_sd"
